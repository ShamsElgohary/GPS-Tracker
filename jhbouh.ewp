# IAR project jhbouh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: app.c app.h common_macros.h delay.c delay.h gps_driver.c gps_driver.h lcd.c lcd.h led.c led.h main.c os.c os.h port.c port.h std_types.h systick.c systick.h tm4c123gh6pm_registers.h uart.c uart.h uart_to_pc.c uart_to_pc.h
